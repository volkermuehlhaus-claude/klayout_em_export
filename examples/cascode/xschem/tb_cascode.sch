** sch_path: examples/cascode/xschem/tb_cascode.sch
**.subckt tb_cascode
x1 Cas_out Cas_in Cas_Bias cascode_em_dc_ngspice
Cin Cas_in in 10p m=1
Lb vb Cas_in 1u m=1
Vin in GND dc 0 ac 1 portnum 1 z0 50
Cout out Cas_out 10p m=1
Lc vcc Cas_out 1u m=1
Vout out GND dc 0 ac 0 portnum 2 z0 50
Vcc vcc GND 2.5
Vb vb GND 0.9
Vbias Cas_Bias GND 1.9
**** begin user architecture code

.lib $::SG13G2_MODELS/cornerHBT.lib hbt_typ



.control
op
print -i(Vcc) -i(Vbias)
sp lin 200 1g 200g
let s21db = db(S_2_1)
meas sp s21_10g find s21db at=10g
meas sp s21_100g find s21db at=100g
write tb_cascode.raw
.endc


**** end user architecture code
**.ends

* expanding   symbol:  cascode_em_dc_ngspice.sym # of pins=3
** sym_path: examples/cascode/xschem/cascode_em_dc_ngspice.sym
.include [file join [file dirname [abs_sym_path @symname.sym]] cascode_em_dc_ngspice.cir]
.GLOBAL GND
.end
